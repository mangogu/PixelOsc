# Keil uVision project myOsc.uvprojx, settings and files
target myOsc (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: myOsc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\myDriver;..\myMiddile;..\myAPI;..\myFonts;..\myOS;..\myDriver\Cube_Driver\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\myDriver\Cube_Driver\ST\STM32_USB_Host_Library\Core\Inc;..\myDriver\Cube_Driver\Third_Party\FatFs\src;..\myMiddile\FATFS\App;..\myMiddile\FATFS\Target;..\myMiddile\USBHOST\App;..\myMiddile\USBHOST\Target
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_spi.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_hcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_usb.c
  group myDriver
    ../myDriver/: LTDC.c GPIO.c TIM.c SPI.c SYSTICK.c USART.c DAC.c I2C.c
  group myMiddle
    ../myMiddile/: LCD.c FLASH.c
  group myAPI
    ../myAPI/: GUI.c CTR.c demo_spi_flash.c CONFIG.c FILE.c BMP.c CMD.c BTNFUNC.c POWER.c
  group myFonts
    ../myFonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group myOS
    ../myOS/: myOS.c
  group myDriver_FatFs
    ../myDriver/Cube_Driver/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../myDriver/Cube_Driver/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group myDriver_USB_Host_Lib
    ../myDriver/Cube_Driver/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../myDriver/Cube_Driver/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group myMiddle_FatFs_Target
    ../myMiddile/FATFS/Target/: usbh_diskio.c
  group myMiddle_FatFs_App
    ../myMiddile/FATFS/App/: fatfs.c
  group myMiddle_USBHOST_Target
    ../myMiddile/USBHOST/Target/: usbh_conf.c
  group myMiddle_USBHOST_App
    ../myMiddile/USBHOST/App/: usb_host.c
software components: CMSIS:CORE 4.3.0
